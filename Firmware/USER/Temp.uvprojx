# Keil uVision project Temp.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\Hardware\LED;..\Hardware\KEY;..\Hardware\TimeBase;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\EXTIs;..\Hardware\Osc;..\Hardware\PWM;..\Shell2;..\Hardware\OLED;..\Hardware\RTC;..\Hardware\DS18B20;..\STM32F10x_DSP_Lib\inc;..\Hardware\DAC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: system_stm32f10x.c main.c Clock.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group Hardware
    ../Hardware/LED/: LED.c
    ../Hardware/KEY/: Key.c
    ../Hardware/TimeBase/: TimeBase.c
    ../Hardware/Osc/: Osc.c
    ../Hardware/PWM/: PWM.c
    ../Hardware/OLED/: oled.c
    ../Hardware/RTC/: rtc.c
    ../Hardware/DS18B20/: ds18b20.c
    ../Hardware/DAC/: DAC.c
    ./: WaveGen.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group Shell
    ../Shell2/: ArrayOperation.c Shell2.c
  group DSP_FFT
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../STM32F10x_DSP_Lib/src/: cr4_fft_256_stm32.s
